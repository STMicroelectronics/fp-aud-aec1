# IAR project Project.ewp, settings and files
configuration STM32F746-Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746ZG ST STM32F746ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; USE_STM32F7XX_NUCLEO_144; STM32F746xx; USE_USB_FS; ARM_MATH_CM7; DISABLE_USB_DRIVEN_ACQUISITION
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\Middlewares\ST\STM32_AcousticEC_Library\Inc; ..\..\..\..\..\Drivers\BSP\CCA01M1; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\AUDIO_IN_OUT\Inc; ..\..\..\..\..\Drivers\BSP\STM32F7xx_Nucleo_144; ..\..\..\..\..\Drivers\BSP\CCA02M2; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Drivers\BSP\Components\sta350bw; ..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\Common\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f746xx.s
  group Application/User
    ../Src/: audio_application.c main.c nucleo_f746zg_bus.c stm32f7xx_it.c usbd_audio_if.c usbd_conf_f7.c usbd_desc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/CCA01M1
    ../../../../../Drivers/BSP/CCA01M1/: cca01m1_audio.c
  group Drivers/BSP/CCA02M2
    ../../../../../Drivers/BSP/CCA02M2/: cca02m2_audio.c
  group Drivers/BSP/Components/STA350BW
    ../../../../../Drivers/BSP/Components/sta350bw/: sta350bw.c sta350bw_reg.c
  group Drivers/BSP/STM32F7xx-Nucleo
    ../../../../../Drivers/BSP/STM32F7xx_Nucleo_144/: stm32f7xx_nucleo_144.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_ll_usb.c
  group Middlewares/ST/STM32_Audio/AEC
    ../../../../../Middlewares/ST/STM32_AcousticEC_Library/Src/: acousticEC.c echo.c Echo_library.c filterbank.c preprocess.c smallft.c
  group Middlewares/ST/STM32_Audio/PDM
    ../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM7_IAR_wc32.a
  group Middlewares/STM32_USBD_Library/Class/Audio
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO_IN_OUT/Src/: usbd_audio_in_out.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
